/*
 * Laufschrift auf der 8x13-LED-Matrix des Arduino UNO Q
 * ------------------------------------------------------
 * TEXT unten anpassen - unterstuetzt: a-z (Grossbuchstaben werden
 * automatisch klein), 0-9 und  . , : - _ ! ? ' + / ( )
 *
 * Verwendung in Arduino App Lab:
 *   My Apps -> "Create new app +" -> Inhalt von sketch/sketch.ino
 *   durch diesen Code ersetzen -> Run.
 */

#include <Arduino_LED_Matrix.h>
#include <ctype.h>
#include <string.h>

// ===================== HIER DEN TEXT EINTRAGEN =====================
const char TEXT[]  = "raspberry.tips";
const int SPEED_MS = 80;   // ms pro Spalte (kleiner = schneller)
// ===================================================================

Arduino_LED_Matrix matrix;

const int COLS = 13;
const int ROWS = 8;

// Pixelfont: 8 Zeilen hoch, Bit 0 = oberste Zeile, variable Breite
const char    FONT_CHARS[] = "abcdefghijklmnopqrstuvwxyz0123456789 .,:-_!?'+/()";
const uint8_t FONT_W[]     = {4, 4, 4, 4, 4, 3, 4, 4, 2, 3, 4, 1, 5, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 3, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 3, 2, 2, 2, 3, 4, 1, 4, 1, 3, 3, 2, 2};
const uint8_t FONT_C[][5]  = {
  {0x20, 0x54, 0x54, 0x78, 0x00},
  {0x7F, 0x44, 0x44, 0x38, 0x00},
  {0x38, 0x44, 0x44, 0x44, 0x00},
  {0x38, 0x44, 0x44, 0x7F, 0x00},
  {0x38, 0x54, 0x54, 0x58, 0x00},
  {0x7E, 0x05, 0x05, 0x00, 0x00},
  {0x18, 0xA4, 0xA4, 0x7C, 0x00},
  {0x7F, 0x04, 0x04, 0x78, 0x00},
  {0x44, 0x7D, 0x00, 0x00, 0x00},
  {0x40, 0x84, 0x7D, 0x00, 0x00},
  {0x7F, 0x10, 0x28, 0x44, 0x00},
  {0x7F, 0x00, 0x00, 0x00, 0x00},
  {0x7C, 0x04, 0x7C, 0x04, 0x78},
  {0x7C, 0x04, 0x04, 0x78, 0x00},
  {0x38, 0x44, 0x44, 0x38, 0x00},
  {0xFC, 0x24, 0x24, 0x18, 0x00},
  {0x18, 0x24, 0x24, 0xFC, 0x00},
  {0x7C, 0x08, 0x04, 0x04, 0x00},
  {0x48, 0x54, 0x54, 0x24, 0x00},
  {0x04, 0x3F, 0x44, 0x44, 0x00},
  {0x3C, 0x40, 0x40, 0x7C, 0x00},
  {0x0C, 0x30, 0x40, 0x30, 0x0C},
  {0x3C, 0x40, 0x30, 0x40, 0x3C},
  {0x6C, 0x10, 0x6C, 0x00, 0x00},
  {0x1C, 0xA0, 0xA0, 0x7C, 0x00},
  {0x64, 0x54, 0x4C, 0x44, 0x00},
  {0x3E, 0x41, 0x41, 0x3E, 0x00},
  {0x42, 0x7F, 0x40, 0x00, 0x00},
  {0x62, 0x51, 0x49, 0x46, 0x00},
  {0x21, 0x45, 0x45, 0x3A, 0x00},
  {0x0C, 0x0A, 0x7F, 0x08, 0x00},
  {0x27, 0x45, 0x45, 0x39, 0x00},
  {0x3E, 0x45, 0x45, 0x38, 0x00},
  {0x01, 0x71, 0x0D, 0x03, 0x00},
  {0x3A, 0x45, 0x45, 0x3A, 0x00},
  {0x06, 0x49, 0x49, 0x3E, 0x00},
  {0x00, 0x00, 0x00, 0x00, 0x00},
  {0xC0, 0xC0, 0x00, 0x00, 0x00},
  {0x80, 0x40, 0x00, 0x00, 0x00},
  {0x6C, 0x6C, 0x00, 0x00, 0x00},
  {0x10, 0x10, 0x10, 0x00, 0x00},
  {0x80, 0x80, 0x80, 0x80, 0x00},
  {0x5F, 0x00, 0x00, 0x00, 0x00},
  {0x02, 0x51, 0x09, 0x06, 0x00},
  {0x03, 0x00, 0x00, 0x00, 0x00},
  {0x10, 0x38, 0x10, 0x00, 0x00},
  {0x60, 0x1C, 0x03, 0x00, 0x00},
  {0x3E, 0x41, 0x00, 0x00, 0x00},
  {0x41, 0x3E, 0x00, 0x00, 0x00}
};

const int MAX_COLS = 1200;      // reicht fuer ~200 Zeichen
uint8_t banner[MAX_COLS];
int bannerLen = 0;

void buildBanner() {
  bannerLen = 0;
  for (unsigned int i = 0; i < strlen(TEXT); i++) {
    char ch = tolower((unsigned char) TEXT[i]);
    const char *p = strchr(FONT_CHARS, ch);
    int idx = p ? (int)(p - FONT_CHARS) : (int) strlen(FONT_CHARS) - 1;
    if (!p) { ch = ' '; p = strchr(FONT_CHARS, ' '); idx = (int)(p - FONT_CHARS); }
    for (int c = 0; c < FONT_W[idx] && bannerLen < MAX_COLS - 1; c++) {
      banner[bannerLen++] = FONT_C[idx][c];
    }
    if (bannerLen < MAX_COLS - 1) banner[bannerLen++] = 0;  // Zeichenabstand
  }
}

uint8_t frame[ROWS * COLS];

void setup() {
  matrix.begin();
  matrix.setGrayscaleBits(1);
  buildBanner();
}

void loop() {
  static int offset = -COLS;   // Text laeuft leer ein

  for (int x = 0; x < COLS; x++) {
    int src = offset + x;
    uint8_t col = (src >= 0 && src < bannerLen) ? banner[src] : 0;
    for (int y = 0; y < ROWS; y++) {
      frame[y * COLS + x] = (col >> y) & 1;
    }
  }
  matrix.draw(frame);

  offset++;
  if (offset > bannerLen) {
    offset = -COLS;            // von vorn
  }
  delay(SPEED_MS);
}
